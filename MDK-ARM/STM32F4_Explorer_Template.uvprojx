# Keil uVision project STM32F4_Explorer_Template.uvprojx, settings and files
target STM32F4_Explorer_Template (5060960::V5.06 update 7 for Certification (build 960)::.\ARMCC)
  device: GD32F470ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4_Explorer_Template +hex
  AfterMake: ..\getKeilOutput.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Applications;../Modules/agile_dbg;../Modules/CherryRB-1.0.0;../Modules/console;../Modules/letter-shell-shell2.x;../Modules/task_run;..\Modules\lwip-2.1.2\src\include;..\Modules\port\lwip;..\Modules\drivers\eth;..\Modules\mbtcp_master;..\Modules\agile_modbus\inc;..\Modules\agile_modbus\util;..\Modules\tool_com;..\Modules\tcp_server;..\Modules\com_tcp
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep shellCommand*
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_eth.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Applications
    ../Applications/: system.c
  group drivers
    ../Modules/drivers/eth/: drv_eth.c
  group LwIP/api
    ../Modules/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP/core
    ../Modules/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Modules/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group LwIP/netif
    ../Modules/lwip-2.1.2/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c zepif.c
  group LwIP/arch
    ../Modules/port/lwip/netif/: ethernetif.c
    ../Modules/port/lwip/arch/: sys_arch.c
    ../Modules/port/lwip/: lwip_cmd.c
  group LwIP/apps
    ../Modules/lwip-2.1.2/src/apps/netbiosns/: netbiosns.c
  group Modules/console
    ../Modules/console/: syscalls.c console.c
  group Modules/CherryRB
    ../Modules/CherryRB-1.0.0/: chry_ringbuffer.c
  group Modules/letter-shell
    ../Modules/letter-shell-shell2.x/: shell.c shell_ext.c
  group Modules/task_run
    ../Modules/task_run/: task_run.c
  group Modules/mbtcp_master
    ../Modules/mbtcp_master/: mbtcp_master.c
  group Modules/agile_modbus
    ../Modules/agile_modbus/src/: agile_modbus.c agile_modbus_rtu.c agile_modbus_tcp.c
    ../Modules/agile_modbus/util/: agile_modbus_slave_util.c
  group Modules/tool_com
    ../Modules/tool_com/: tool_com.c
  group Modules/tcp_server
    ../Modules/tcp_server/: tcp_server.c
  group Modules/com_tcp
    ../Modules/com_tcp/: com_tcp.c
software components: CMSIS:CORE 5.6.0
